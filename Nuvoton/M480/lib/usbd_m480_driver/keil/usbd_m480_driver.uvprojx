# Keil uVision project usbd_m480_driver.uvprojx, settings and files
target usbd_m480_driver (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.7
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: usbd_m480_driver (library)
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\M480_BSP_CMSIS\Library\CMSIS\Include;..\..\M480_BSP_CMSIS\Library\Device\Nuvoton\M480\Include;..\..\M480_BSP_CMSIS\Library\StdDriver\inc;..\..\..\..\..\core\lib\threadx\common\inc;..\..\..\..\..\core\lib\threadx\ports\cortex_m4\keil\inc;..;..\..\..\..\..\core\lib\usbx\common\core\inc;..\..\..\..\..\core\lib\usbx\common\usbx_device_classes;..\..\..\..\..\core\lib\usbx\ports\cortex_m4\keil\inc;..\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Source
    ../src/: ux_dcd_m480_slave_address_set.c ux_dcd_m480_slave_endpoint_create.c ux_dcd_m480_slave_endpoint_destroy.c ux_dcd_m480_slave_endpoint_reset.c ux_dcd_m480_slave_endpoint_stall.c ux_dcd_m480_slave_endpoint_status.c ux_dcd_m480_slave_frame_number_get.c ux_dcd_m480_slave_function.c ux_dcd_m480_slave_transfer_token_hs.c ux_dcd_m480_slave_initialize.c ux_dcd_m480_slave_initialize_complete.c ux_dcd_m480_slave_state_change.c ux_dcd_m480_slave_transfer_abort.c ux_dcd_m480_slave_transfer_request.c ux_dcd_m480_slave_transfer_request_hs.c ux_dcd_m480_slave_transfer_token.c ux_dcd_m480_slave_handler.c ux_dcd_m480_slave_handler_hs.c
