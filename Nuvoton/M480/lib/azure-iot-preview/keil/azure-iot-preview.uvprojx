# Keil uVision project azure-iot-preview.uvprojx, settings and files
target azure-iot-preview_wifi (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.7
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: azure-iot-preview_wifi (library)
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\..\core\lib\threadx\common\inc;..\..\..\..\..\core\lib\threadx\ports\cortex_m4\keil\inc;..\..\netxduo_wifi\common\inc;..\..\netxduo_wifi\ports\cortex_m4\keil\inc;..\..\netxduo_wifi\addons\dns;..\..\netxduo_wifi\addons\mqtt;..\..\netxduo_wifi\nx_secure\inc;..\..\netxduo_wifi\nx_secure\ports;..\..\..\..\..\core\lib\azure-iot-preview\azure_iot;..\..\..\..\..\core\lib\azure-iot-preview\nx_cloud;..\..\..\..\..\core\lib\azure-iot-preview\azure_iot\azure-sdk-for-c\sdk\inc;..\..\..\..\..\core\lib\azure-iot-preview\azure_iot\azure-sdk-for-c\sdk\inc\azure\core;..\..\..\..\..\core\lib\azure-iot-preview\azure_iot\azure-sdk-for-c\sdk\inc\azure\core\internal;..\..\..\..\..\core\lib\azure-iot-preview\azure_iot\azure-sdk-for-c\sdk\inc\azure\iot;..\..\..\..\..\core\lib\azure-iot-preview\azure_iot\azure-sdk-for-c\sdk\inc\azure\iot\internal;..\..\..\..\..\core\lib\azure-iot-preview\azure_iot\azure-sdk-for-c\sdk\inc\azure\storage;..\..\..\..\..\core\lib\azure-iot-preview\azure_iot\azure-sdk-for-c\sdk\inc\azure\storage\internal
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group azure_iot
    ../../../../../core/lib/azure-iot-preview/azure_iot/: nx_azure_iot.c nx_azure_iot_hub_client.c nx_azure_iot_provisioning_client.c
  group nx_cloud
    ../../../../../core/lib/azure-iot-preview/nx_cloud/: nx_cloud.c
  group azure-sdk-for-c_core
    ../../../../../core/lib/azure-iot-preview/azure_iot/azure-sdk-for-c/sdk/src/azure/core/: az_aad.c az_context.c az_credential_client_secret.c az_credential_token.c az_http_pipeline.c az_http_policy.c az_http_policy_logging.c az_http_policy_retry.c az_http_request.c az_http_response.c az_json_reader.c az_json_token.c az_json_writer.c az_log.c az_precondition.c az_span.c az_spinlock.c
  group azure-sdk-for-c_iot
    ../../../../../core/lib/azure-iot-preview/azure_iot/azure-sdk-for-c/sdk/src/azure/iot/: az_iot_common.c az_iot_hub_client.c az_iot_hub_client_c2d.c az_iot_hub_client_methods.c az_iot_hub_client_sas.c az_iot_hub_client_telemetry.c az_iot_hub_client_twin.c az_iot_provisioning_client.c az_iot_provisioning_client_sas.c
  group azure-sdk-for-c_platform
    ../../../../../core/lib/azure-iot-preview/azure_iot/azure-sdk-for-c/sdk/src/azure/platform/: az_nohttp.c az_noplatform.c
  group azure-sdk-for-c_storage
    ../../../../../core/lib/azure-iot-preview/azure_iot/azure-sdk-for-c/sdk/src/azure/storage/: az_storage_blobs_blob_client.c
