# Keil uVision project netx_esp8266_driver.uvprojx, settings and files
target netx_esp8266_driver (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.7
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: netx_esp8266_driver (library)
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\M480_BSP_CMSIS\Library\CMSIS\Include;..\..\M480_BSP_CMSIS\Library\Device\Nuvoton\M480\Include;..\..\M480_BSP_CMSIS\Library\StdDriver\inc;..\..\..\..\..\core\lib\threadx\common\inc;..\..\..\..\..\core\lib\threadx\ports\cortex_m4\keil\inc;..\..\netxduo_wifi\common\inc;..\..\netxduo_wifi\ports\cortex_m4\keil\inc;..\buffer;..\driver;..\platform;..
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Source
    ../buffer/: esp_buffer.c
    ../driver/: esp_ll.c
    ../platform/: esp_platform.c
    ../: esp8266_wifi.c nx_wifi.c
