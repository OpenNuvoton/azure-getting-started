# Keil uVision project demo_azure_iot.uvproj, settings and files
target demo_azure_iot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x9FFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: demo_azure_iot
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: JSMN_STATIC
  c include: ..\..\..\lib\M480_BSP_CMSIS\Library\CMSIS\Include;..\..\..\lib\M480_BSP_CMSIS\Library\Device\Nuvoton\M480\Include;..\..\..\lib\M480_BSP_CMSIS\Library\StdDriver\inc;..\..\..\..\..\core\lib\threadx\common\inc;..\..\..\..\..\core\lib\threadx\ports\cortex_m4\keil\inc;..\..\..\lib\netxduo_wifi\common\inc;..\..\..\lib\netxduo_wifi\ports\cortex_m4\keil\inc;..\..\..\lib\netxduo_wifi\nx_secure\inc;..\..\..\lib\netxduo_wifi\nx_secure\ports;..\..\..\lib\netxduo_wifi\addons\dns;..\..\..\lib\netxduo_wifi\addons\mqtt;..\..\..\lib\netxduo_wifi\addons\sntp;..\..\..\lib\netx_esp8266_driver;..\..\..\..\..\core\lib\jsmn\src;..\..\..\..\..\core\lib\azure-iot-preview\nx_cloud;..\..\..\..\..\core\lib\azure-iot-preview\azure_iot;..\..\..\..\..\core\lib\azure-iot-preview\azure_iot\azure-sdk-for-c\sdk\inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0xa000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\startup\keil\M480_azure_rtos.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group Device
    ../../startup/keil/: startup_M480_azure_rtos.s tx_initialize_low_level.s
    ../../../lib/M480_BSP_CMSIS/Library/Device/Nuvoton/M480/Source/: system_M480.c
  group Lib
    ../../lib/keil/: azure-iot-preview_wifi.lib netx_esp8266_driver.lib netxduo_wifi.lib ThreadX_Library.lib
  group StdDriver
    ../../../lib/M480_BSP_CMSIS/Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c
  group User
    ../: main.c myapp_utils.c netx_esp8266_network.c nx_azure_iot_cert.c nx_azure_iot_ciphersuites.c sample_azure_iot_embedded_sdk.c sample_device_identity.c sntp_client.c
