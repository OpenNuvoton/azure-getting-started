# Keil uVision project demo_netx_esp8266.uvproj, settings and files
target demo_netx_esp8266 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x9FFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: demo_netx_esp8266
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\lib\M480_BSP_CMSIS\Library\CMSIS\Include;..\..\..\lib\M480_BSP_CMSIS\Library\Device\Nuvoton\M480\Include;..\..\..\lib\M480_BSP_CMSIS\Library\StdDriver\inc;..\..\..\..\..\core\lib\threadx\common\inc;..\..\..\..\..\core\lib\threadx\ports\cortex_m4\keil\inc;..\..\..\lib\netxduo_wifi\common\inc;..\..\..\lib\netxduo_wifi\ports\cortex_m4\keil\inc;..\..\..\lib\netxduo_wifi\addons\dns;..\..\..\lib\netx_esp8266_driver;..
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0xa000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\startup\keil\M480_azure_rtos.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group Device
    ../../startup/keil/: startup_M480_azure_rtos.s tx_initialize_low_level.s
    ../../../lib/M480_BSP_CMSIS/Library/Device/Nuvoton/M480/Source/: system_M480.c
  group Lib
    ../../lib/keil/: netx_esp8266_driver.lib netxduo_wifi.lib ThreadX_Library.lib
  group StdDriver
    ../../../lib/M480_BSP_CMSIS/Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c
  group User
    ../: main.c myapp_utils.c netx_esp8266_network.c
